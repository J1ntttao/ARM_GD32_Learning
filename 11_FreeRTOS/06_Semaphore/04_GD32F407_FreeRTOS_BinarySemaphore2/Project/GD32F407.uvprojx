# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407_EC12 +hex
  AfterMake: ./keil5_disp_size_bar.exe
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: SYS_SUPPORT_OS
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware;..\Library;..\Library\I2C;..\App;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F;..\Hardware\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group App
    ../App/: App.h
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Hardware
    ../Hardware/: bsp_keys.c
    ../Hardware/OLED/: oled.c
  group Library
    ../Library/: USART0.c EXTI.c TIMER.c
    ../Library/I2C/: I2C.c I2C0.c I2C2.c
    ../Library/SPI/: SPI.c SPI1.c
  group Library/configs
    ../Library/SPI/: SPI_config.h
    ../Library/I2C/: I2C_config.h
    ../Library/: TIMER_config.h EXTI_config.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_dma.c gd32f4xx_i2c.c gd32f4xx_adc.c gd32f4xx_spi.c
  group Doc
    ../Doc/: readme.txt
  group FreeRTOS/Core
    ../FreeRTOS/: tasks.c queue.c list.c timers.c event_groups.c
  group FreeRTOS/Port
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
  group FreeRTOS
    ../FreeRTOS/include/: FreeRTOSConfig.h
