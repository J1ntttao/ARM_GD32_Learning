# Keil uVision project GD32F407.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.4.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F407
  c misc: -Wno-invalid-source-encoding
  c include: ..\User;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\Firmware\GD32F4xx_standard_peripheral\Include;..\Hardware;..\Library;..\Library\I2C
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Library
    ../Library/: USART0.c EXTI.c TIMER.c SPI0.c SPI0.h
  group Library/I2C
    ../Library/I2C/: I2C.c I2C0.c I2C_config.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_gpio.c gd32f4xx_usart.c gd32f4xx_exti.c gd32f4xx_syscfg.c gd32f4xx_dma.c gd32f4xx_timer.c gd32f4xx_i2c.c gd32f4xx_adc.c gd32f4xx_spi.c gd32f4xx_pmu.c
  group Hardware
    ../Hardware/: bsp_leds.c PCF8563.c bsp_w25q64.h bsp_w25q64.c
    ../Hardware/SPI_OLED/: oled.c
  group Doc
    ../Doc/: readme.txt
